FILESEXTRAPATHS_prepend := "${THISDIR}/opkg-collateral:"

